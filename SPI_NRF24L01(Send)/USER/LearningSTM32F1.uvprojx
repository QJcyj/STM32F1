# Keil uVision project LearningSTM32F1.uvprojx, settings and files
target LereningSTM32F1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LearningSTM32F1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\StartupFile;..\USER;.\delay;.\LED;.\Key;..\communication;.\adc;..\module
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group TheKernel
    ../StartupFile/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c sys.c
  group USER
    ./: main.c
  group LED
    ./LED/: led.c
  group delay
    ./delay/: delay.c
  group key
    ./Key/: key.c
  group communication
    ../communication/: usart.c SPI.c
  group adc
    ./adc/: adc.c
  group module
    ../module/: NRF24L01.c
